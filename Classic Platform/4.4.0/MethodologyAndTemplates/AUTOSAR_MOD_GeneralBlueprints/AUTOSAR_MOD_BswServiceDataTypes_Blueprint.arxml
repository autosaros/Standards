[part 3 of 3: packages /AUTOSAR/V2x_GeneralTypes/ImplementationDataTypes_Blueprint to /AUTOSAR/WdgM/ImplementationDataTypes_Blueprint]
AUTOSAR XML (schema 00046)
package /AUTOSAR/V2x_GeneralTypes/ImplementationDataTypes_Blueprint
  impl type V2xM_PositionAndTimeType: category=STRUCTURE
    11 x element, all with category=TYPE_REFERENCE:
      latitude: implementation-data-type=sint32
      longitude: implementation-data-type=sint32
      altitude: implementation-data-type=sint32
      speed: implementation-data-type=sint16
      heading: implementation-data-type=uint16
      timestamp: implementation-data-type=uint32
      semiMajorConfidence: implementation-data-type=uint16
      semiMinorConfidence: implementation-data-type=uint16
      semiMajorOrientation: implementation-data-type=uint16
      pai: implementation-data-type=boolean
      informationValid: implementation-data-type=boolean
  impl type V2xM_SecReportType:
    compu {0x00=V2X_SECREP_SUCCESS, 0x01=V2X_SECREP_FALSE_SIGNATURE, 0x02=V2X_SECREP_INVALID_CERTIFICATE, 0x03=V2X_SECREP_REVOKED_CERTIFICATE, 0x04=V2X_SECREP_INCONSISTENT_CHAIN, 0x05=V2X_SECREP_INVALID_TIMESTAMP, 0x06=V2X_SECREP_DUPLICATE_MESSAGE, 0x07=V2X_SECREP_INVALID_MOBILITY_DATA, 0x08=V2X_SECREP_UNSIGNED_MESSAGE, 0x09=V2X_SECREP_SIGNER_CERTIFICATE_NOT_FOUND, 0x0a=V2X_SECREP_UNSUPPORTED_SIGNER_IDENTIFIER_TYPE, 0x0b=V2X_SECREP_INCOMPATIBLE_PROTOCOL, 0x0c=V2X_SECREP_UNENCRYPTED_MESSAGE, 0x0d=V2X_SECREP_DECRYPTION_ERROR, 0xff=V2X_SECREP_NONE}
    range raw 0x00..0xff
    implementation-data-type=uint8
package /AUTOSAR/WdgM/ImplementationDataTypes_Blueprint
  5 x impl type, all with category=TYPE_REFERENCE:
    WdgM_CheckpointIdType: range raw 0..undefined, implementation-data-type=uint16, variation-point=blueprint-condition=verbatim=l-5=Maximum number of Checkpoints > 255
    WdgM_GlobalStatusType: compu {4=WDGM_GLOBAL_STATUS_DEACTIVATED, 2=WDGM_GLOBAL_STATUS_EXPIRED, 1=WDGM_GLOBAL_STATUS_FAILED, 0=WDGM_GLOBAL_STATUS_OK, 3=WDGM_GLOBAL_STATUS_STOPPED}, range raw 0..4, implementation-data-type=uint8
    WdgM_LocalStatusType: compu {0=WDGM_LOCAL_STATUS_OK, 1=WDGM_LOCAL_STATUS_FAILED, 2=WDGM_LOCAL_STATUS_EXPIRED, 4=WDGM_LOCAL_STATUS_DEACTIVATED}, range raw 0..4, implementation-data-type=uint8
    WdgM_ModeType: range raw 0..undefined, implementation-data-type=uint8
    WdgM_SupervisedEntityIdType: range raw 0..undefined, implementation-data-type=uint16, variation-point=blueprint-condition=verbatim=l-5=Maximum number of Supervised Entities > 255 -> uint16
